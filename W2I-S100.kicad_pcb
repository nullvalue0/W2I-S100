# Repository nullvalue0/W2I-S100 (continued)

## KiCad design W2I-S100.kicad_pcb (continued)

Board: 6 copper layers, 219 parts (0 on the bottom side), 265 nets, no tracks yet.

File Gerbers/W2I-S100-BOM.csv (part):

"Reference","Qty","Value","LCSC Part","DNP","Exclude from BOM","Exclude from Board","Footprint","Datasheet"
"BZ1","1","Buzzer","","","","","Buzzer_Beeper:Buzzer_12x9.5RM7.6","~"
"C1,C6,C8,C9,C10,C11,C13,C15,C16,C17,C18,C24,C25,C26,C27,C28,C29,C30,C31,C32,C36,C37,C38,C40,C41,C42,C44,C45,C46,C47,C48,C49,C50,C51,C52,C53,C54,C55,C56,C57,C58,C59,C60,C61,C62,C63,C64,C65,C66,C67,C68,C69,C74,C75,C77,C78","56","0.1uF","C1590","","","","footprints:C0603","https://lcsc.com/product-detail/Multilayer-Ceramic-Capacitor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"
"C2,C3,C4","3","1.0uF","C29936","","","","footprints:C0603","https://lcsc.com/product-detail/Multilayer-Ceramic-Capacitor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"
"C5","1","4.7uF","C264246","","","","footprints:CAP-SMD_BD4.0-L4.3-W4.3-LS5.3-FD","https://lcsc.com/product-detail/Others_Semtech-CK1E4R7M0405_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"
"C7,C19","2","47uF","C141425","","","","footprints:CAP-SMD_BD6.3-L6.6-W6.6-FD","https://lcsc.com/product-detail/Aluminum-Electrolytic-Capaci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"
"C12,C14,C71,C73","4","10uF","C3343","","","","footprints:CAP-SMD_BD4.0-L4.3-W4.3-FD","https://lcsc.com/product-detail/Aluminum-Electrolytic-Capaci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"
"C20","1","22uF","C2762594","","","","footprints:C0603",""
"C21,C22,C23","3","470pF","C519395","","","","footprints:C0603","~"
"C33,C34,C35,C39","4","47pF","C519392","","","","footprints:C0603","~"
"C43","1","22pF","C519390","","","","footprints:C0603","~"
"C70,C72","2","33uF","C249892","","","","footprints:CAP-SMD_BD6.3-L6.6-W6.6-FD","https://lcsc.com/product-detail/Others_Lelon-VZH330M1E0606-T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,https://lcsc.com/product-detail/Others_Semtech-CK1E4R7M0405_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"
"C76","1",".33uF","C1615","","","","footprints:C0603","https://lcsc.com/product-detail/Multilayer-Ceramic-Capacitor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"
"D1","1","1N4148W T4","C2099","","","","footprints:SOD-123_L2.8-W1.8-LS3.7-RD","https://lcsc.com/product-detail/Switching-Diode_1N4148W-T4_C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"
"D3","1","BAT41","","","","","Diode_THT:D_DO-35_SOD27_P7.62mm_Horizontal","http://www.vishay.com/docs/85659/bat41.pdf"
"J1","1","to WDI","","","","","Connector_IDC:IDC-Header_2x17_P2.54mm_Vertical","SBH11-PBPC-D17-ST-BK"
"J2","1","44-pin IDE","","","","","footprints:SAMTEC-SQT-122-01-X-D-RA",""
"J3","1","Serial","","","","","Connector_PinHeader_2.54mm:PinHeader_1x05_P2.54mm_Vertical","~"
"J4","1","40-pin IDE","","","","","Connector_IDC:IDC-Header_2x20_P2.54mm_Vertical","~"
"J5","1","EXT PWR","","","","","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","~"
"J6","1","Jumper to enable buzzer","","","","","Connector_PinHeader_2.54mm:PinHeader_2x01_P2.54mm_Vertical","~"
"J7","1","Conn_01x02_Pin","","","","","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","~"
"LED1,LED2,LED3,LED4","4","YELLOW","C84261","","","","footprints:LED0805-R-RD","https://lcsc.com/product-detail/Light-Emitting-Diodes-LED_Ye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"
"LED5,LED7,LED8","3","GREEN","C84260","","","","footprints:LED0805-R-RD","https://lcsc.com/product-detail/Light-Emitting-Diodes-LED_Em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"
"LED6,LED9,LED11,LED12,LED13","5","RED","C84256","","","","footprints:LED0805-R-RD","https://lcsc.com/product-detail/Light-Emitting-Diodes-LED_Re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"
"OSC1","1","ECS-2100AX-3.6864MHZ","","","","","Oscillator:Oscillator_DIP-8","http://cdn-reichelt.de/documents/datenblatt/B400/OSZI.pdf"
"OSC2","1","ACHL-27.000MHZ-EK","","","","","Oscillator:Oscillator_DIP-8","http://cdn-reichelt.de/documents/datenblatt/B400/OSZI.pdf"
"OSC3","1","22.5792MHz","C7431407","","","","footprints:OSC-SMD_4P-L7.0-W5.0-BL-2",""
"P1","1","S100_MALE","","","","","",""
"P7","1","5V Reg","","","","","Connector_PinHeader_2.54mm:PinHeader_1x05_P2.54mm_Vertical","~"
"Q1","1","2N2222AU","C21714170","","","","footprints:SOT-89-3_L4.5-W2.4-P1.50-LS4.0-BR",""
"R1,R2,R3,R4","4","270","C22966","","","","footprints:R0603","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R5,R7,R8","3","160","C22814","","","","footprints:R0603","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R6,R9,R22,R31,R50","5","360","C25194","","","","footprints:R0603","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R10","1","100","","","","","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal","~"
"R11,R12,R13","3","100K","C17900","","","","footprints:R1206","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R14,R30","2","270K","C17940","","","","footprints:R1206","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R15,R17,R23,R24,R25,R26,R27,R28,R29","9","4.7K","C17936","","","","footprints:R1206","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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,https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R16","1","22K","C114942","","","","footprints:R1206","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R18","1","47K","C25833","","","","footprints:R1206","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R32","1","2.2K","C17948","","","","footprints:R1206","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R33,R37,R39,R41,R46,R47,R52","7","1K","C1469","","","","footprints:R1206","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R34,R35,R36","3","15K","C25828","","","","footprints:R1206","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R38,R53","2","1.5K","C26030","","","","footprints:R1206","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R40","1","470","C4502","","","","footprints:R1206","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R44,R45","2","33","C18005","","","","footprints:R1206","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R48","1","5.6K","C18028","","","","footprints:R1206","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R49","1","10K","C17902","","","","footprints:R1206","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"R51","1","100","C17901","","","","footprints:R1206","https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount-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"
"RP1","1","761-5-R220/330","","","","","Package_DIP:DIP-16_W7.62mm","~"
"RP2","1","4x100Ω","","","","","Resistor_THT:R_Array_SIP8","http://www.vishay.com/docs/31509/csc.pdf"
"SW1","1","SW_DIP_x07","","","","","Package_DIP:DIP-14_W7.62mm","~"
"TP1","1","2s timer output","","","","","TestPoint:TestPoint_THTPad_2.0x2.0mm_Drill1.0mm","~"
"TP2","1","50ns W60h pulse","","","","","TestPoint:TestPoint_THTPad_2.0x2.0mm_Drill1.0mm","~"
"TP3","1","50ns R60h pulse","","","","","TestPoint:TestPoint_THTPad_2.0x2.0mm_Drill1.0mm","~"
"TP4","1","50ns delayed W60h pulse","","","","","TestPoint:TestPoint_THTPad_2.0x2.0mm_Drill1.0mm","~"
"TP5","1","50ns burst clock trigger","","","","","TestPoint:TestPoint_THTPad_2.0x2.0mm_Drill1.0mm","~"
"TP6","1","50ns primer clock trigger","","","","","TestPoint:TestPoint_THTPad_2.0x2.0mm_Drill1.0mm","~"
"TP7","1","22.579MHz clock","","","","","TestPoint:TestPoint_THTPad_2.0x2.0mm_Drill1.0mm","~"
"TP8,TP9,TP14","3","GND","","","","","TestPoint:TestPoint_THTPad_2.0x2.0mm_Drill1.0mm","~"
"TP10","1","+8V","","","","","TestPoint:TestPoint_THTPad_2.0x2.0mm_Drill1.0mm","~"
"TP11","1","+5V","","","","","TestPoint:TestPoint_THTPad_2.0x2.0mm_Drill1.0mm","~"
"TP12","1","+16V","","","","","TestPoint:TestPoint_THTPad_2.0x2.0mm_Drill1.0mm","~"
"TP13","1","-16V","","","","","TestPoint:TestPoint_THTPad_2.0x2.0mm_Drill1.0mm","~"
"U1","1","Z80CPU","","","","","Package_DIP:DIP-40_W15.24mm","www.zilog.com/manage_directlink.php?filepath=docs/z80/um0080"
"U2","1","28C256","","","","","Package_DIP:DIP-28_W15.24mm","http://ww1.microchip.com/downloads/en/DeviceDoc/doc0006.pdf"
"U3","1","CY62256NLL-55ZXIT","C2759940","","","","footprints:TSOP-28_L11.8-W8.0-P0.55-LS13.4-B_CYPRESS",""
"U4","1","2681","","","","","Package_DIP:DIP-24_W10.16mm","~"
"U5","1","MAX232A","","","","","Package_DIP:DIP-16_W7.62mm","http://www.ti.com/lit/ds/symlink/max232.pdf"
"U6,U7","2","74F74","C6805","","","","footprints:SOIC-14_L8.7-W3.9-P1.27-LS6.0-BL","https://lcsc.com/product-detail/74-Series_TI_SN74F74DR_SN74F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"
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